# Keil uVision project circular_buffer.uvprojx, settings and files
target Circular buffer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: circular_buffer
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: circular_buffer.c circular_buffer.h
    ./test/: test_circular_buffer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
